CMDLINE:append = " snd_bcm2835.enable_headphones=1"
